FILESEXTRAPATHS_prepend := "${THISDIR}/device-tree-overlays:"

TEZI_EXTERNAL_KERNEL_DEVICETREE_BOOT_verdin-imx8mp += ""